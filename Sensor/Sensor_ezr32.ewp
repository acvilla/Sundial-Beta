# IAR project Sensor_ezr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EZR32LG330F256R60 SiliconLaboratories EZR32LG330F256R60
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SOURCEFILE__="$FILE_FNAME$"; CONNECT_PHY_OPTION=0; PHY_PRO2; BOARD_HEADER="brd4502c.h"; EZR32WG330F256R60; EZR32WG330F256; CORTEXM3_EZR32WG330F256; NULL_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; ENABLE_EXT_DEVICE; PRO2_RADIO_BOOT_MODE=1; DEBUG_LEVEL=0; HAL_MICRO; BOARD_EZR32; EMBER_STACK_CONNECT; CONFIGURATION_HEADER="connect-configuration.h"; PLATFORM_HEADER="micro/cortexm3/compiler/iar.h"; EMBER_ASSERT_SERIAL_PORT=2; MAP_MAC_PG0_CHANNELS=0; NUM_EP_USED=3; NUM_APP_TIMERS=0; APPLICATION_TOKEN_HEADER="connect-token.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/stack; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/hal; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/hal/micro/cortexm3/efm32/board; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/phy; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/common/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/rtcdrv/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/rtcdrv/test; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/sleep/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/dmadrv/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/radio/test/src; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/gpiointerrupt/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/config; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/uartdrv/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/ustimer/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/spidrv/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emlib/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/rtcdrv/inc; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/CMSIS/Include; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/kits/common/bsp; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/kits/common/drivers; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/hal/micro/cortexm3/efm32; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/Device/SiliconLabs/; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/kits/SLWSTK6200A_EZR32LG/config; ..\..\..\..\..\SiliconLabs\SiliconLabsConnect\SiliconLabsConnect\submodules\usb\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsConnect\SiliconLabsConnect\connect\plugins\stack\include; ..\..\..\..\..\SiliconLabs\SiliconLabsConnect\SiliconLabsConnect\connect\plugins\usb; ..\..\..\..\..\SiliconLabs\SiliconLabsConnect\SiliconLabsConnect\connect\plugins\usb\usb-cdc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect\connect; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect\connect\plugins; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect\submodules\base\hal\; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/hal/micro/cortexm3/efm32/board; ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect\submodules\base\; ..\..\..\..\..\SiliconLabs\SiliconLabsConnect\SiliconLabsConnect\submodules\usb\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsConnect\SiliconLabsConnect\connect\plugins\stack\include; ..\..\..\..\..\SiliconLabs\SiliconLabsConnect\SiliconLabsConnect\connect\plugins\usb; ..\..\..\..\..\SiliconLabs\SiliconLabsConnect\SiliconLabsConnect\connect\plugins\usb\usb-cdc
  OBJCOPY.OOCOutputFile: Sensor.bin
  ILINK.IlinkOutputFile: Sensor.out
  ILINK.IlinkConfigDefines: BTL_SIZE=0K; NULL_BTL=1
  ILINK.IlinkIcfFile: ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/hal/micro/cortexm3/efm32/ezr32lg330f256/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/libraries/: aes-security-library.a form-and-join-library.a hal-library.a packet-queue-library.a parent-support-library.a phy-pro2-brd4502c-library.a sim-eeprom1-library.a stack-common-library.a stack-counters-library.a xxtea-security-library.a
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/command-interpreter/: command-interpreter.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/debug-print/: debug-print.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/heartbeat/: heartbeat.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/idle-sleep/: idle-sleep.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/main/: main.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/poll/: poll.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/serial/: com.c ember-printf.c serial.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/stack/config/: ember-configuration.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/usb/: descriptors.c usb-common.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/usb/usb-cdc/: usb-cdc-cli.c usb-cdc.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/connect/plugins/wstk-sensors/: wstk-sensors.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/hal/micro/cortexm3/efm32/: assert-crash-handlers.c button.c buzzer.c cstartup-common.c diagnostic.c ext-device.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c symbol-timer.c token-def.c token.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/base/phy/pro2class/: phy-config-connect.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/Device/SiliconLabs/EZR32WG/Source/: system_ezr32wg.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/dmadrv/src/: dmadrv.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/sleep/src/: sleep.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/spidrv/src/: spidrv.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/uartdrv/src/: uartdrv.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emdrv/ustimer/src/: ustimer.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/kits/common/bsp/: bsp_stk_leds.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/kits/common/drivers/: dmactrl.c i2cspm.c si7013.c udelay.c
    ../../../../../SiliconLabs/SiliconLabsConnect/SiliconLabsConnect/submodules/usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
    ./: connect-bookkeeping.c connect-callback-stubs.c connect-callbacks.c connect-cli.c connect-events.c
