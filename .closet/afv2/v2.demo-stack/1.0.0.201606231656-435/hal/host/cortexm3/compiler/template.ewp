# IAR project template.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; ../../..; ../../../stack; ../../../ReplaceGlobalBaseDir/HAL; ../../../ReplaceGlobalBaseDir; ../../../ReplaceGlobalBaseDir/hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../../ReplaceGlobalBaseDir/hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../../ReplaceGlobalBaseDir/hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: $FILE_DIR$; ../../..; ../../../stack; ../../../ReplaceGlobalBaseDir/hal; ../../../ReplaceGlobalBaseDir/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../../ReplaceGlobalBaseDir/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../../ReplaceGlobalBaseDir/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc
  OBJCOPY.OOCOutputFile: ReplaceOutFileName.s37
  ILINK.IlinkOutputFile: ReplaceOutFileName.out
  ILINK.IlinkIcfFile: ../../../ReplaceICFConfigFileName
  ILINK.IlinkProgramEntryLabel: __iar_program_start
