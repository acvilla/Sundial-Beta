# IAR project template-iar.ewp, settings and files
configuration Normal-Banked (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDiagSuppress: Pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\stack\; ..\..\..\ReplaceGlobalBaseDir\hal\; ..\..\..\ReplaceGlobalBaseDir\; ..\..\..\submodules\external\timac\cobra\Projects\mac\common\cc2530; ..\..\..\submodules\external\timac\cobra\Components\hal\include; ..\..\..\submodules\external\timac\cobra\Components\hal\target\CC2530EB; ..\..\..\submodules\external\timac\cobra\Components\mac\include; ..\..\..\submodules\external\timac\cobra\Components\mac\high_level; ..\..\..\submodules\external\timac\cobra\Components\mac\low_level\srf04; ..\..\..\submodules\external\timac\cobra\Components\mac\low_level\srf04\single_chip; ..\..\..\submodules\external\timac\cobra\Components\mt; ..\..\..\submodules\external\timac\cobra\Components\osal\include; ..\..\..\submodules\external\timac\cobra\Components\services\saddr; ..\..\..\submodules\external\timac\cobra\Components\services\sdata
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "..\..\..\submodules\external\timac\cobra\tools\oad.exe" "..\$TARGET_BNAME$.sim" "..\$TARGET_BNAME$.bin"
  XLINK.XclFile: ../../../ReplaceICFConfigFileName
