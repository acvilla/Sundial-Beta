# Keil uVision project template-uv4.uvproj, settings and files
target ReplaceProjectName (MCS-51)
  device: C8051F930 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: ReplaceProjectName
  c flags: Optimize=12
  link misc: RU CODE DW(13)
