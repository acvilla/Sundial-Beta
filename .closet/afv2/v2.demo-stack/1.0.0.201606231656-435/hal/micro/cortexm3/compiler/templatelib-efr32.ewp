# IAR project templatelib-efr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\ReplaceGlobalBaseDir\HAL\; ..\..\..\ReplaceGlobalBaseDir\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\ReplaceGlobalBaseDir\HAL\; ..\..\..\ReplaceGlobalBaseDir\; ..\..\..\ReplaceGlobalBaseDir\rtos\FreeRTOS\; ..\..\..\ReplaceGlobalBaseDir\rtos\FreeRTOS\Source\; ..\..\..\ReplaceGlobalBaseDir\rtos\FreeRTOS\Source\include; ..\..\..\ReplaceGlobalBaseDir\rtos\FreeRTOS\Source\portable\IAR\ARM_CM3
  ILINK.IlinkProgramEntryLabel: halEntryPoint
