# IAR project template-v5-min.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\ReplaceGlobalBaseDir\HAL\; ..\..\..\ReplaceGlobalBaseDir\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ReplaceD79FileName.s37
  ILINK.IlinkOutputFile: ReplaceD79FileName.out
  ILINK.IlinkIcfFile: ../../../ReplaceICFConfigFileName
