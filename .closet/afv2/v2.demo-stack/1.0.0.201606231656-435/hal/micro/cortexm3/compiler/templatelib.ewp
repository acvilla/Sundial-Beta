# IAR project templatelib.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\ReplaceGlobalBaseDir\HAL\; ..\..\..\ReplaceGlobalBaseDir\
  XLINK.XclFile: ..\..\..\hal\micro\cortexm3\em350\iar-cfg.xcl
